FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

HDF_BASE = "file://"
HDF_PATH = "zedboard_led_gpio.xsa"

