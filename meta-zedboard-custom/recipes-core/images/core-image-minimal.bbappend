# Automatically install our custom led-blink C application into the rootfs
IMAGE_INSTALL:append = " led-blink"

